# Keil uVision project vrunst.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fourWheel
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Core;..\Libraries\inc;..\Driver;..\User;..\User\eMPL
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../User/: system_stm32f10x.c stm32f10x_it.c main.c sch.c
  group LIB
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_iwdg.c
  group CORE
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group DRIVER
    ../Driver/: adc.c gpio.c delay.c pwm.c pid.c iwdg.c uart1.c key.c
    ../User/: mpu6050.c
    ../User/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group DOC
    ./: readme.txt
